<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>file_sink_example</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>record</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>label</key><value>Record?</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>tag_now</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Tag Now</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>sandia_utils_file_monitor</key>
<param><key>id</key><value>sandia_utils_file_monitor_0</value></param>
<param><key>copy_data</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>nfiles</key><value>10</value></param>
<param><key>output_path</key><value>/tmp</value></param>
</block>
<block>
<key>sandia_utils_file_sink</key>
<param><key>id</key><value>sandia_utils_file_sink_0</value></param>
<param><key>align</key><value>False</value></param>
<param><key>create_new_dir</key><value>False</value></param>
<param><key>directory</key><value>/mnt/ramdisk</value></param>
<param><key>nsamples</key><value>10*int(samp_rate)</value></param>
<param><key>name_spec</key><value>"%03fd.fc32"</value></param>
<param><key>file_type</key><value>raw</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mode</key><value>sandia_utils.MANUAL</value></param>
<param><key>record</key><value>record</value></param>
<param><key>rate</key><value>int(samp_rate)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>timing_utils_add_usrp_tags_c</key>
<param><key>id</key><value>timing_utils_add_usrp_tags_c_0</value></param>
<param><key>freq</key><value>915e6</value></param>
<param><key>rate</key><value>int(samp_rate)</value></param>
<param><key>tag_now</key><value>tag_now</value></param>
<param><key>tf</key><value>.5</value></param>
<param><key>ti</key><value>123456789</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>timing_utils_add_usrp_tags_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>sandia_utils_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sandia_utils_file_sink_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>msg</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>sandia_utils_file_sink_0</source_block_id><sink_block_id>sandia_utils_file_monitor_0</sink_block_id><source_key>msg</source_key><sink_key>pdu</sink_key></connection>
<connection><source_block_id>timing_utils_add_usrp_tags_c_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>timing_utils_add_usrp_tags_c_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
