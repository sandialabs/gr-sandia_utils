options:
  parameters:
    generate_options: qt_gui
    id: file_sink_example
    output_language: python
  states: {}

blocks:
- name: record
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Record?
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: tag_now
  id: variable_qtgui_push_button
  parameters:
    label: Tag Now
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: sandia_utils_file_monitor_0
  id: sandia_utils_file_monitor
  parameters:
    copy_data: 'False'
    nfiles: '10'
    output_path: /tmp
  states: {state: disabled}
- name: sandia_utils_file_sink_1
  id: sandia_utils_file_sink
  parameters:
    align: 'False'
    create_new_dir: 'False'
    directory: '"/mnt/ramdisk"'
    file_type: raw
    mode: sandia_utils.MANUAL
    name_spec: '"%Y%m%d_%H_%M_%S_fc=%fcMHz_fs=%fskHz.dat"'
    nsamples: int(320e3)
    rate: int(samp_rate)
    record: 'True'
    type: complex
    vlen: '1'
  states: {}
- name: timing_utils_add_usrp_tags_c_0
  id: timing_utils_add_usrp_tags_c
  parameters:
    freq: 915e6
    rate: int(samp_rate)
    tag_now: tag_now
    tf: '.5'
    ti: '123456789'
  states: {}

connections:
- [analog_sig_source_x_0, '0', timing_utils_add_usrp_tags_c_0, '0']
- [blocks_throttle_0, '0', sandia_utils_file_sink_1, '0']
- [sandia_utils_file_sink_1, msg, blocks_message_debug_0, print]
- [sandia_utils_file_sink_1, msg, sandia_utils_file_monitor_0, pdu]
- [timing_utils_add_usrp_tags_c_0, '0', blocks_tag_debug_0, '0']
- [timing_utils_add_usrp_tags_c_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
