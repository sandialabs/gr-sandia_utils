options:
  parameters:
    generate_options: qt_gui
    id: stream_gate_example
    output_language: python
  states: {}

blocks:
- name: consume0
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: '[1,0,1,1]'
    label: 'Channel 0: Consume'
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: consume1
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: '[1,1,1,1]'
    label: 'Channel 1: Consume'
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: flow0
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: '[0,0,1,1]'
    label: 'Channel 0: Flow'
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: flow1
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: '[0,1,1,1]'
    label: 'Channel 1: Flow'
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30.72e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: '[2,0,1,1]'
    showports: 'True'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: '[2,1,1,1]'
    showports: 'True'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: sandia_utils_stream_gate_0
  id: sandia_utils_stream_gate
  parameters:
    consume_data: consume0
    flow_data: flow0
    type: cc
  states: {}
- name: sandia_utils_stream_gate_0_0
  id: sandia_utils_stream_gate
  parameters:
    consume_data: consume1
    flow_data: flow1
    type: cc
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', sandia_utils_stream_gate_0, '0']
- [blocks_throttle_0, '0', sandia_utils_stream_gate_0_0, '0']
- [sandia_utils_stream_gate_0, '0', qtgui_waterfall_sink_x_0, '0']
- [sandia_utils_stream_gate_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
